options:
  parameters:
    generate_options: qt_gui
    id: Spectrograph
    output_language: python
    title: Spectrograph
  states: {}

blocks:
- name: bw
  id: variable_qtgui_range
  parameters:
    label: Bandwidth (kHz)
    start: '200'
    step: '100'
    stop: '30000'
    value: '20000'
  states: {}
- name: channel_n
  id: variable
  parameters:
    value: int(bw/channel_w)
  states: {}
- name: channel_w
  id: variable_qtgui_range
  parameters:
    label: Channelization width (kHz)
    rangeType: int
    start: resolution
    step: '10'
    stop: bw
    value: '200'
    widget: counter
  states: {}
- name: decay
  id: variable
  parameters:
    value: 1-10**-decay_N
  states: {}
- name: decay_N
  id: variable_qtgui_range
  parameters:
    label: Jammer memory decay rate (1-10^-N)
    start: '0'
    step: '0.5'
    stop: '10'
    value: '3'
    widget: counter
  states: {}
- name: fcenter
  id: variable_qtgui_range
  parameters:
    label: Center frequency (MHz)
    start: '88'
    step: '10'
    stop: '1000'
    value: '468'
  states: {}
- name: fft_n
  id: variable
  parameters:
    value: int(bw/resolution)
  states: {}
- name: indices
  id: variable
  parameters:
    value: '[int(i * fft_n/channel_n) for i in range(channel_n + 1)]'
  states: {}
- name: j_permanence
  id: variable
  parameters:
    value: '[0]*fft_n'
  states: {}
- name: jammer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: resolution
  id: variable_qtgui_range
  parameters:
    label: Frequency resolution (kHz)
    rangeType: int
    start: '1'
    step: int(bw/200)
    stop: bw
    value: '25'
    widget: counter
  states: {state: disabled}
- name: resolution
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    label: RX Gain (dB)
    start: '1'
    step: '0.1'
    stop: '60'
    value: '34'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_k*bw*1e3
  states: {}
- name: samp_rate_k
  id: variable_qtgui_range
  parameters:
    label: Sampling rate multiplier
    rangeType: int
    start: '2'
    step: '1'
    stop: '10'
    value: '2'
    widget: counter
  states: {state: disabled}
- name: samp_rate_k
  id: variable
  parameters:
    value: '2'
  states: {}
- name: threshold_c
  id: variable
  parameters:
    value: 1+threshold_percent/100
  states: {}
- name: threshold_percent
  id: variable_qtgui_range
  parameters:
    label: Threshold value (%)
    rangeType: int
    start: '10'
    step: '10'
    stop: '300'
    value: '150'
    widget: counter
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum raw
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/ADC_raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    alias: Spectrum magnitude
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/spectrum_raw_mag
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum complex
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/spectrum_raw_complex
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_0_0
  id: blocks_file_sink
  parameters:
    alias: Jammer detection per channel file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/jamming_presence
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_1_0
  id: blocks_file_sink
  parameters:
    alias: Jammer indicator log file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/jamming_indicator
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_1_0_0
  id: blocks_file_sink
  parameters:
    alias: Center frequency log file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/logs
    type: float
    vlen: '5'
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_1_0_0_0
  id: blocks_file_sink
  parameters:
    alias: Jamming memory file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/persistent_jamming_presence
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_2
  id: blocks_file_sink
  parameters:
    alias: Channel power magnitude file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/channel_power_mag
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '5'
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_n
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          """
          docstring for block Observer
          """
          def __init__(self, fft_n = 800, channel_n = 100, fcenter = 468.000, bw = 20000000,
          threshold_c = 2.5, jammer = 0, j_permanence = [0]*800, decay = 0.99999):
              gr.sync_block.__init__(self, name="Observer @ Python block",
                  in_sig=[(np.float32, fft_n)],
                  out_sig=[(np.float32, fft_n), (np.float32, fft_n), np.float32, (np.float32, 5), (np.float32, fft_n)]
                  #Port explanations:
                  #(0) channel power levels for the batch, (1) jammer detection per channel,
                  #(2) jammer detection for the batch, (3) logs for the batch (center freq, bandwidth), (4) memory of jammer in channel
              )
              self.fft_n = fft_n
              self.channel_n = channel_n
              self.fcenter = fcenter
              self.threshold_c = threshold_c
              self.bw = bw
              self.j_permanence = j_permanence
              self.decay = decay

          def set_fft_n(self, fft_n):
              self.fft_n = fft_n
          def set_channel_n(self, channel_n):
              self.channel_n = channel_n
          def set_fcenter(self, fcenter):
              self.fcenter = fcenter
          def set_threshold_c(self, threshold_c):
              # print("Updating threshold_c from,", self.threshold_c, " to")
              self.threshold_c = threshold_c
              # print(self.threshold_c)
              # print("Done updating.")
          def set_bw(self, bw):
              self.bw = bw
          # def set_j_permanence(self, j_permanence):
          #     # print("Updating j_permanence from,", self.j_permanence, " to")
          #     self.j_permanence = j_permanence
          #     # print(self.j_permanence)
          #     # print("Done updating.")
          def set_decay(self,decay):
              self.decay = decay


          def work(self, input_items, output_items):
              processed = len(input_items[0])
              indices = [int(i*self.fft_n/self.channel_n) for i in range(self.channel_n + 1)]

              for vIndex in range(processed):
                  #Get channel statistics and power
                  for channel in range(len(indices)-1):
                      # print("len(indices)", len(indices), "channel_n", self.channel_n)
                      # print("(channel, channel + 1)", (channel,channel+1))
                      #Sum power over spectrum channel
                      channel_sum = np.sum(input_items[0][vIndex][indices[channel]:indices[channel+1]])
                      #Number of datapoints in the channel.
                      sample_n = indices[channel+1]-indices[channel]
                      #Set channel power over each member of the channel. Avoid creating variable output vector sizes with variable channel sizes.
                      output_items[0][vIndex][indices[channel]:indices[channel+1]] = np.full(sample_n, channel_sum/sample_n, dtype = np.float32)
                  
                  #See if channels pop over threshold multiple of average spectrum power
                  spectrum_sum = np.sum(output_items[0][vIndex][indices[:-1]])
                  spectrum_ave = spectrum_sum/self.channel_n 
                  present = 0 #Indicator of jammer anywhere in the spectrum
                  mask = output_items[0][vIndex][indices[:-1]] > spectrum_ave * self.threshold_c
                  #At some point change 3.16 to self.threshold_c once you figure out why it keeps returning 0.
                  # DEBUG some variables and indexing issues
                  # print("vector at channel border")
                  # print(output_items[0][vIndex][indices[:-1]])
                  # print("spectrum sum: ", spectrum_sum)
                  # print("amplified spectrum average")
                  # print(spectrum_sum/self.channel_n,",",spectrum_ave,",", spectrum_ave*self.threshold_c)
                  # print("spectrum threshold calculation:", spectrum_ave*self.threshold_c)
                  # print("threshold:", self.threshold_c)
                  # print(mask)
                  for channel in range(len(indices)-1):
                      # print("len(indices)", len(indices), "channel_n", self.channel_n)
                      # print("(channel, channel + 1)", (channel,channel+1))
                      output_items[1][vIndex][indices[channel]:indices[channel+1]] = mask[channel]
                      self.j_permanence[indices[channel]:indices[channel+1]] = np.full(sample_n, self.j_permanence[indices[channel]]*self.decay + mask[channel]*(1-self.decay), dtype = np.float32)
                      output_items[4][vIndex][indices[channel]:indices[channel+1]] = self.j_permanence[indices[channel]]
                  present = int(np.any(mask))  #Note any jammer detection over spectrum
                  
                  #Jammer detection channel
                  output_items[2][vIndex] = present
                  #Set log data
                  output_items[3][vIndex][0:5] = [self.fcenter, self.bw, self.fft_n, self.channel_n, self.threshold_c]

              return processed
    bw: bw
    channel_n: channel_n
    decay: '0.99'
    fcenter: fcenter
    fft_n: fft_n
    j_permanence: j_permanence
    jammer: jammer
    threshold_c: threshold_c
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_n
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_n)
  states: {}
- name: observerBlockTest_observerBlockTest_0
  id: observerBlockTest_observerBlockTest
  parameters:
    alias: Observer test platform
    bw: bw
    channel_n: channel_n
    decay: decay
    fcenter: fcenter
    fft_n: fft_n
    jammer: jammer
    threshold_c: threshold_c
  states: {state: disabled}
- name: observerBlock_Observer_1
  id: observerBlock_Observer
  parameters:
    bw: '20000000'
    channel_n: channel_n
    decay: '0.99999'
    fcenter: fcenter
    fft_n: fft_n
    jammer: jammer
    threshold_c: threshold_c
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '3'
    size: fft_n
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alias: Spectrograph
    bw: bw*1e3
    fc: fcenter
    fftsize: '512'
    grid: 'True'
    type: complex
    update_time: '0.001'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    alias: USRP 2910 observer
    ant0: '"RX2"'
    bw0: bw*1E3
    center_freq0: fcenter*1E6
    gain0: rxgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_stream_mux_0, '1']
- [blocks_complex_to_mag_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_complex_to_real_0, '0', blocks_stream_mux_0, '0']
- [blocks_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_0, '0']
- [blocks_stream_to_vector_1, '0', observerBlockTest_observerBlockTest_0, '0']
- [blocks_stream_to_vector_1, '0', observerBlock_Observer_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_file_sink_0_1_2_2, '0']
- [blocks_vector_to_stream_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_2_0_0, '0', blocks_file_sink_0_1_2_0_0, '0']
- [blocks_vector_to_stream_2_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_stream_2_0_0_0, '0', blocks_file_sink_0_1_2_1_0_0_0, '0']
- [blocks_vector_to_stream_2_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_vector_to_stream_2_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [epy_block_0, '0', blocks_vector_to_stream_2, '0']
- [epy_block_0, '1', blocks_vector_to_stream_2_0_0, '0']
- [epy_block_0, '2', blocks_file_sink_0_1_2_1_0, '0']
- [epy_block_0, '2', blocks_null_sink_0, '0']
- [epy_block_0, '3', blocks_file_sink_0_1_2_1_0_0, '0']
- [epy_block_0, '3', blocks_null_sink_0_0, '0']
- [epy_block_0, '4', blocks_vector_to_stream_2_0_0_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [observerBlockTest_observerBlockTest_0, '0', blocks_file_sink_0_1_2_2, '0']
- [observerBlockTest_observerBlockTest_0, '0', qtgui_time_sink_x_0, '0']
- [observerBlockTest_observerBlockTest_0, '1', blocks_file_sink_0_1_2_0_0, '0']
- [observerBlockTest_observerBlockTest_0, '1', qtgui_time_sink_x_0, '1']
- [observerBlockTest_observerBlockTest_0, '2', blocks_file_sink_0_1_2_1_0, '0']
- [observerBlockTest_observerBlockTest_0, '2', blocks_null_sink_0, '0']
- [observerBlockTest_observerBlockTest_0, '3', blocks_file_sink_0_1_2_1_0_0, '0']
- [observerBlockTest_observerBlockTest_0, '3', blocks_null_sink_0_0, '0']
- [observerBlockTest_observerBlockTest_0, '4', blocks_file_sink_0_1_2_1_0_0_0, '0']
- [observerBlockTest_observerBlockTest_0, '4', blocks_null_sink_0_0_0, '0']
- [observerBlockTest_observerBlockTest_0, '4', qtgui_time_sink_x_0, '2']
- [observerBlock_Observer_1, '0', blocks_vector_to_stream_2, '0']
- [observerBlock_Observer_1, '1', blocks_vector_to_stream_2_0_0, '0']
- [observerBlock_Observer_1, '2', blocks_file_sink_0_1_2_1_0, '0']
- [observerBlock_Observer_1, '2', blocks_null_sink_0, '0']
- [observerBlock_Observer_1, '3', blocks_file_sink_0_1_2_1_0_0, '0']
- [observerBlock_Observer_1, '3', blocks_null_sink_0_0, '0']
- [observerBlock_Observer_1, '4', blocks_vector_to_stream_2_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_imag_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
