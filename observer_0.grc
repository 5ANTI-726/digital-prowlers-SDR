options:
  parameters:
    generate_options: qt_gui
    id: Spectrograph
    output_language: python
    title: Spectrograph
  states: {}

blocks:
- name: bw
  id: variable_qtgui_range
  parameters:
    label: Bandwidth (kHz)
    start: '200'
    step: '100'
    stop: '30000'
    value: '10000'
  states: {}
- name: channel_n
  id: variable
  parameters:
    value: int(bw/channel_w)
  states: {}
- name: channel_w
  id: variable_qtgui_range
  parameters:
    label: Channelization width (kHz)
    rangeType: int
    start: '10'
    step: '10'
    stop: bw
    value: '250'
    widget: counter
  states: {}
- name: fcenter
  id: variable_qtgui_range
  parameters:
    label: Center frequency (MHz)
    start: '88'
    step: '0.025'
    stop: '3400'
    value: '910'
  states: {}
- name: fft_n
  id: variable
  parameters:
    value: int(bw/resolution)
  states: {}
- name: indices
  id: variable
  parameters:
    value: '[int(i * fft_n/channel_n) for i in range(channel_n + 1)]'
  states: {}
- name: jammer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: resolution
  id: variable_qtgui_range
  parameters:
    label: Frequency resolution (kHz)
    rangeType: int
    start: '1'
    step: int(bw/200)
    stop: bw
    value: '25'
    widget: counter
  states: {state: disabled}
- name: resolution
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    label: RX Gain (dB)
    start: '1'
    step: '0.1'
    stop: '60'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_k*bw*1e3
  states: {}
- name: samp_rate_k
  id: variable_qtgui_range
  parameters:
    label: Sampling rate multiplier
    rangeType: int
    start: '2'
    step: '1'
    stop: '10'
    value: '2'
    widget: counter
  states: {state: disabled}
- name: samp_rate_k
  id: variable
  parameters:
    value: '2'
  states: {}
- name: threshold_c
  id: variable
  parameters:
    value: 1+threshold_percent/100
  states: {}
- name: threshold_percent
  id: variable_qtgui_range
  parameters:
    label: Threshold value (%)
    rangeType: int
    start: '10'
    step: '10'
    stop: '300'
    value: '100'
    widget: counter
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum raw
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/ADC_raw
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    alias: Spectrum magnitude
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/spectrum_raw_mag
    type: float
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum complex
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/spectrum_raw_complex
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_1
  id: blocks_file_sink
  parameters:
    alias: Spectrum vectorized power
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/spectrum_vector_mag
    type: float
    vlen: fft_n
  states: {state: disabled}
- name: blocks_file_sink_0_1_2
  id: blocks_file_sink
  parameters:
    alias: Channel power magnitude
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/channel_power_mag
    type: float
  states: {}
- name: blocks_file_sink_0_1_2_0
  id: blocks_file_sink
  parameters:
    alias: Jammer detection
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/jamming_presence
    type: float
  states: {}
- name: blocks_file_sink_0_1_2_1
  id: blocks_file_sink
  parameters:
    alias: Center frequency log
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/fcenter_logging
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: fft_n
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_n
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np # type: ignore
      from gnuradio import gr # type: ignore

      class blk(gr.sync_block):
          def __init__(self, fft_n = 400, channel_n = 50, indices = None, fcenter = 910.000):
              gr.sync_block.__init__(
                  self,
                  name='Spectrum power channelizer',
                  in_sig=[(np.float32,fft_n)],
                  out_sig=[(np.float32,fft_n), np.float32]
              )
              self.fft_n = fft_n
              self.channel_n = channel_n
              self.indices = indices
              self.fcenter = fcenter

          def set_fft_n(self, fft_n):
              self.fft_n = fft_n
          def set_channel_n(self, channel_n):
              self.channel_n = channel_n   
          def set_indices(self, indices):
              self.indices = indices
          def set_fcenter(self,fcenter):
              self.fcenter = fcenter

          def work(self, input_items, output_items):
              processed = len(input_items[0])

              for vIndex in range(processed):
                  for channel in range(self.channel_n):
                      output_items[0][vIndex][self.indices[channel]:self.indices[channel+1]]= (self.indices[channel+1]-self.indices[channel])*[np.mean(input_items[0][vIndex][self.indices[channel]:self.indices[channel+1]])]
                  output_items[1][vIndex] = self.fcenter
                  # output_items[0][vIndex][:] = [
                  #     # sum(input_items[0][vIndex][indices[jIndex]:indices[jIndex+1]])/(indices[jIndex+1]-indices[jIndex]+1) for jIndex in range(self.channel_n)
                  #     np.mean(input_items[0][vIndex][indices[jIndex]:indices[jIndex+1]]) for jIndex in range(self.channel_n)
                  # ]

              return processed

          # def work(self, input_items, output_items):
          #     for vIndex in range(len(input_items[0])):
          #         for channel in range(self.channel_n-1):
          #             output_items[0][vIndex][channel] = np.mean(input_items[0][vIndex][int(channel*self.fractional_channel):int((channel+1)*self.fractional_channel)-1])
          #         output_items[0][vIndex][self.channel_n-1] = np.mean(input_items[0][vIndex][int((self.channel_n-1)*self.fractional_channel):self.fft_n])
                  
          #     return len(output_items[0])
    alias: Specturm power channelizer
    channel_n: channel_n
    fcenter: fcenter
    fft_n: fft_n
    indices: indices
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np # type: ignore
      from gnuradio import gr # type: ignore

      class blk(gr.sync_block):
          def __init__(self, fft_n = 400, channel_n = 50, indices = None, threshold_c = 1.5, jammer = 0):
              gr.sync_block.__init__(
                  self,
                  name='Threshold jamming detector',
                  in_sig=[(np.float32,fft_n)],
                  out_sig=[(np.float32,fft_n), (np.float32,1)]
              )
              self.fft_n = fft_n
              self.channel_n = channel_n
              self.indices = indices
              self.threshold_c = threshold_c

          def set_fft_n(self, fft_n):
              self.fft_n = fft_n
          def set_channel_n(self, channel_n):
              self.channel_n = channel_n        
          def set_indices(self, indices):
              self.indices = indices
          def set_threshold_c(self, threshold_c):
              self.threshold_c = threshold_c

          def work(self, input_items, output_items):
              processed = len(input_items[0])

              for vIndex in range(processed):
                  average = sum([input_items[0][vIndex][i+1]for i in self.indices[:-1]])/self.channel_n
                  present = 0
                  for channel in range(self.channel_n):
                      if input_items[0][vIndex][self.indices[channel]] > average*self.threshold_c:
                          output_items[0][vIndex][self.indices[channel]:self.indices[channel+1]] = 1
                          present = 1
                      else:
                          output_items[0][vIndex][self.indices[channel]:self.indices[channel+1]] = 0
                  output_items[1] = present
                  jammer = present
              return processed
    alias: Threshold jamming detector
    channel_n: channel_n
    fft_n: fft_n
    indices: indices
    jammer: jammer
    threshold_c: threshold_c
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_n
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_n)
  states: {}
- name: qtgui_grbackground_0
  id: qtgui_grbackground
  parameters: {}
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alias: Spectrograph
    bw: bw*1e3
    fc: fcenter
    fftsize: '512'
    grid: 'True'
    type: complex
    update_time: '0.001'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    alias: USRP 2910 observer
    ant0: '"RX2"'
    bw0: bw*1E3
    center_freq0: fcenter*1E6
    gain0: rxgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_stream_mux_0, '1']
- [blocks_complex_to_mag_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_complex_to_real_0, '0', blocks_stream_mux_0, '0']
- [blocks_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_mux_0, '0', blocks_null_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_file_sink_0_1_1, '0']
- [blocks_stream_to_vector_1, '0', blocks_null_sink_0_0_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_0_0_2, '0']
- [blocks_vector_to_stream_1, '0', blocks_file_sink_0_1_2, '0']
- [blocks_vector_to_stream_1, '0', blocks_null_sink_0_0_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_file_sink_0_1_2_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_null_sink_0_0_1_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_1, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '1', blocks_file_sink_0_1_2_1, '0']
- [epy_block_0, '1', blocks_null_sink_0_0_1_1, '0']
- [epy_block_1, '0', blocks_vector_to_stream_1_0, '0']
- [epy_block_1, '1', blocks_null_sink_0_0_1_0_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_imag_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
