options:
  parameters:
    generate_options: qt_gui
    id: Spectrograph
    output_language: python
    title: Spectrograph
  states: {}

blocks:
- name: bw
  id: variable_qtgui_range
  parameters:
    label: Bandwidth (kHz)
    start: '200'
    step: '100'
    stop: '30000'
    value: '10000'
  states: {}
- name: channel_n
  id: variable
  parameters:
    value: int(bw/channel_w)
  states: {}
- name: channel_w
  id: variable_qtgui_range
  parameters:
    label: Channelization width (kHz)
    rangeType: int
    start: resolution
    step: '10'
    stop: bw
    value: '200'
    widget: counter
  states: {}
- name: fcenter
  id: variable_qtgui_range
  parameters:
    label: Center frequency (MHz)
    start: '88'
    step: '10'
    stop: '1000'
    value: '468'
  states: {}
- name: fft_n
  id: variable
  parameters:
    value: int(bw/resolution)
  states: {}
- name: indices
  id: variable
  parameters:
    value: '[int(i * fft_n/channel_n) for i in range(channel_n + 1)]'
  states: {}
- name: j_permanence
  id: variable
  parameters:
    value: '[0]*fft_n'
  states: {}
- name: jammer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: resolution
  id: variable_qtgui_range
  parameters:
    label: Frequency resolution (kHz)
    rangeType: int
    start: '1'
    step: int(bw/200)
    stop: bw
    value: '25'
    widget: counter
  states: {state: disabled}
- name: resolution
  id: variable
  parameters:
    value: '25'
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    label: RX Gain (dB)
    start: '1'
    step: '0.1'
    stop: '60'
    value: '34'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_k*bw*1e3
  states: {}
- name: samp_rate_k
  id: variable_qtgui_range
  parameters:
    label: Sampling rate multiplier
    rangeType: int
    start: '2'
    step: '1'
    stop: '10'
    value: '2'
    widget: counter
  states: {state: disabled}
- name: samp_rate_k
  id: variable
  parameters:
    value: '2'
  states: {}
- name: threshold_c
  id: variable
  parameters:
    value: 1+threshold_percent/100
  states: {}
- name: threshold_percent
  id: variable_qtgui_range
  parameters:
    label: Threshold value (%)
    rangeType: int
    start: '10'
    step: '10'
    stop: '300'
    value: '150'
    widget: counter
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum raw
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/ADC_raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    alias: Spectrum magnitude
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/spectrum_raw_mag
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum complex
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/spectrum_raw_complex
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_0_0
  id: blocks_file_sink
  parameters:
    alias: Jammer detection per channel file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/jamming_presence
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_1_0
  id: blocks_file_sink
  parameters:
    alias: Jammer indicator log file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/jamming_indicator
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_1_0_0
  id: blocks_file_sink
  parameters:
    alias: Center frequency log file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/logs
    type: float
    vlen: '5'
  states: {state: disabled}
- name: blocks_file_sink_0_1_2_2
  id: blocks_file_sink
  parameters:
    alias: Channel power magnitude file
    file: /home/santiago2/Desktop/AFRL competition/Observer code base/channel_power_mag
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '5'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_n
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_n
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_n
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_n)
  states: {}
- name: observerBlock_Observer_1
  id: observerBlock_Observer
  parameters:
    channel_n: channel_n
    fcenter: fcenter
    fft_n: fft_n
    jammer: jammer
    threshold_c: threshold_c
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '2'
    size: fft_n
    srate: samp_rate
    type: float
    ymax: '0.3'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alias: Spectrograph
    bw: bw*1e3
    fc: fcenter
    fftsize: '512'
    grid: 'True'
    type: complex
    update_time: '0.001'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    alias: USRP 2910 observer
    ant0: '"RX2"'
    bw0: bw*1E3
    center_freq0: fcenter*1E6
    gain0: rxgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_stream_mux_0, '1']
- [blocks_complex_to_mag_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_complex_to_real_0, '0', blocks_stream_mux_0, '0']
- [blocks_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', observerBlock_Observer_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_file_sink_0_1_2_2, '0']
- [blocks_vector_to_stream_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_2_0_0, '0', blocks_file_sink_0_1_2_0_0, '0']
- [blocks_vector_to_stream_2_0_0, '0', qtgui_time_sink_x_0, '1']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [observerBlock_Observer_1, '0', blocks_vector_to_stream_2, '0']
- [observerBlock_Observer_1, '1', blocks_vector_to_stream_2_0_0, '0']
- [observerBlock_Observer_1, '2', blocks_file_sink_0_1_2_1_0, '0']
- [observerBlock_Observer_1, '2', blocks_null_sink_0, '0']
- [observerBlock_Observer_1, '3', blocks_file_sink_0_1_2_1_0_0, '0']
- [observerBlock_Observer_1, '3', blocks_null_sink_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_imag_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
